## base_external/Config.in
```kconfig
menu "AESD Packages"

source "$BR2_EXTERNAL_PROJECT_BASE_PATH/package/aesd-assignments/Config.in"

endmenu
```
